VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO FALLBUF
  CLASS CORE ;
  ORIGIN 0 0 ;
  SIZE 0.216 BY 0.27 ;
  SITE asap7sc7p5t ;
  PIN A
    DIRECTION INPUT ;
    USE SIGNAL ;
  END A
  PIN Z
    DIRECTION OUTPUT ;
    USE SIGNAL ;
  END Z
END FALLBUF

END LIBRARY
